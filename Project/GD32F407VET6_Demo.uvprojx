# Keil uVision project GD32F407VET6_Demo.uvprojx, settings and files
target Target_1 (6140001::V6.14.1::ARMCLANG)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GD32F407VET6_Demo +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32F407,HXTAL_VALUE=8000000,USE_USB_FS,LV_CONF_INCLUDE_SIMPLE
  c include: ..\CMSIS;..\CMSIS\GD\GD32F4xx\Include;..\FWLIB\GD32F4xx_standard_peripheral\Include;..\User;..\Platform;..\Platform\usb;..\OS;..\APP;..\ThirdParty;..\ThirdParty\fatfs\inc;..\ThirdParty\lvgl;..\ThirdParty\FreeRTOS\Source\include;..\ThirdParty\FreeRTOS\Source\portable\GCC\ARM_CM4F;..\FWLIB\GD32F4xx_usb_library\driver\Include;..\FWLIB\GD32F4xx_usb_library\device\core\Include;..\FWLIB\GD32F4xx_usb_library\device\class\msc\Include;..\FWLIB\GD32F4xx_usb_library\ustd\common;..\FWLIB\GD32F4xx_usb_library\ustd\class\msc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\GD32F407VET6_Demo.sct
  group User
    ../User/: main.c systick.c gd32f4xx_it.c
  group Platform
    ../Platform/: platform.c bsp_rtc.c bsp_clock.c bsp_usart.c bsp_spi0_bus.c bsp_efs.c bsp_fatfs.c bsp_lv_fs_efs.c bsp_spi_flash.c bsp_st7789.c bsp_cst816.c bsp_lvgl.c bsp_usb_msc.c bsp_potentiometer.c bsp_buzzer.c bsp_keypad.c bsp_button.c bsp_led.c bsp_ntc.c bsp_motor.c bsp_nixie.c bsp_sdcard.c sdcard.c board.h
    ../Platform/usb/: bsp_usb_hw.c usbd_storage_msd.c
  group OS
    ../OS/: os_freertos.c os_bare.c os_config.h os.h freertos_hooks.c freertos_heap_ccm.c FreeRTOSConfig.h
    ../ThirdParty/FreeRTOS/Source/: tasks.c list.c queue.c timers.c event_groups.c stream_buffer.c
    ../ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../ThirdParty/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group LVGL
    ../ThirdParty/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_observer.c lv_refr.c
    ../ThirdParty/lvgl/src/display/: lv_display.c
    ../ThirdParty/lvgl/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    ../ThirdParty/lvgl/src/draw/convert/: lv_draw_buf_convert.c
    ../ThirdParty/lvgl/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    ../ThirdParty/lvgl/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_utils.c lv_draw_vector.c
    ../ThirdParty/lvgl/src/draw/sw/blend/arm2d/: lv_blend_arm2d.c
    ../ThirdParty/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../ThirdParty/lvgl/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
    ../ThirdParty/lvgl/src/draw/sw/blend/riscv_v/: lv_draw_sw_blend_riscv_v_to_rgb888.c
    ../ThirdParty/lvgl/src/draw/sw/blend/sve2/: lv_draw_sw_blend_sve2_to_rgb888.c
    ../ThirdParty/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_vector.c
    ../ThirdParty/lvgl/src/font/binfont_loader/: lv_binfont_loader.c
    ../ThirdParty/lvgl/src/font/fmt_txt/: lv_font_fmt_txt.c
    ../ThirdParty/lvgl/src/font/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../ThirdParty/lvgl/src/font/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ../ThirdParty/lvgl/src/font/imgfont/: lv_imgfont.c
    ../ThirdParty/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../ThirdParty/lvgl/src/font/tiny_ttf/: lv_tiny_ttf.c
    ../ThirdParty/lvgl/src/fs/: lv_fs.c lv_fs_fatfs.c lv_fs_frogfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
    ../ThirdParty/lvgl/src/image/: lv_bin_decoder.c lv_bmp.c lv_image_decoder.c lv_libjpeg_turbo.c lv_libpng.c lv_libwebp.c lv_lodepng.c lv_tjpgd.c
    ../ThirdParty/lvgl/src/image/svg/: lv_svg.c lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
    ../ThirdParty/lvgl/src/indev/: lv_gridnav.c lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../ThirdParty/lvgl/src/layouts/flex/: lv_flex.c
    ../ThirdParty/lvgl/src/layouts/grid/: lv_grid.c
    ../ThirdParty/lvgl/src/layouts/: lv_layout.c
    ../ThirdParty/lvgl/src/logging/: lv_log.c
    ../ThirdParty/lvgl/src/: lv_init.c
    ../ThirdParty/lvgl/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../ThirdParty/lvgl/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../ThirdParty/lvgl/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../ThirdParty/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_bidi_common.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_grad.c lv_iter.c lv_ll.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../ThirdParty/lvgl/src/osal/: lv_os.c lv_os_none.c
    ../ThirdParty/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../ThirdParty/lvgl/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../ThirdParty/lvgl/src/stdlib/: lv_mem.c
    ../ThirdParty/lvgl/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../ThirdParty/lvgl/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../ThirdParty/lvgl/src/stdlib/uefi/: lv_mem_core_uefi.c
    ../ThirdParty/lvgl/src/themes/default/: lv_theme_default.c
    ../ThirdParty/lvgl/src/themes/: lv_theme.c
    ../ThirdParty/lvgl/src/themes/mono/: lv_theme_mono.c
    ../ThirdParty/lvgl/src/themes/simple/: lv_theme_simple.c
    ../ThirdParty/lvgl/src/tick/: lv_tick.c
    ../ThirdParty/lvgl/src/widgets/3dtexture/: lv_3dtexture.c
    ../ThirdParty/lvgl/src/widgets/animimage/: lv_animimage.c
    ../ThirdParty/lvgl/src/widgets/arc/: lv_arc.c
    ../ThirdParty/lvgl/src/widgets/arclabel/: lv_arclabel.c
    ../ThirdParty/lvgl/src/widgets/bar/: lv_bar.c
    ../ThirdParty/lvgl/src/widgets/barcode/: lv_barcode.c
    ../ThirdParty/lvgl/src/widgets/button/: lv_button.c
    ../ThirdParty/lvgl/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../ThirdParty/lvgl/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../ThirdParty/lvgl/src/widgets/canvas/: lv_canvas.c
    ../ThirdParty/lvgl/src/widgets/chart/: lv_chart.c
    ../ThirdParty/lvgl/src/widgets/checkbox/: lv_checkbox.c
    ../ThirdParty/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../ThirdParty/lvgl/src/widgets/ffmpeg/: lv_ffmpeg.c
    ../ThirdParty/lvgl/src/widgets/gif/: lv_gif.c
    ../ThirdParty/lvgl/src/widgets/gstreamer/: lv_gstreamer.c
    ../ThirdParty/lvgl/src/widgets/image/: lv_image.c
    ../ThirdParty/lvgl/src/widgets/imagebutton/: lv_imagebutton.c
    ../ThirdParty/lvgl/src/widgets/ime/: lv_ime_pinyin.c
    ../ThirdParty/lvgl/src/widgets/keyboard/: lv_keyboard.c
    ../ThirdParty/lvgl/src/widgets/label/: lv_label.c
    ../ThirdParty/lvgl/src/widgets/led/: lv_led.c
    ../ThirdParty/lvgl/src/widgets/line/: lv_line.c
    ../ThirdParty/lvgl/src/widgets/lottie/: lv_lottie.c
    ../ThirdParty/lvgl/src/widgets/msgbox/: lv_msgbox.c
    ../ThirdParty/lvgl/src/widgets/objx_templ/: lv_objx_templ.c
    ../ThirdParty/lvgl/src/widgets/property/: lv_animimage_properties.c lv_arc_properties.c lv_bar_properties.c lv_buttonmatrix_properties.c lv_chart_properties.c lv_checkbox_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_led_properties.c lv_line_properties.c lv_obj_properties.c lv_roller_properties.c lv_scale_properties.c lv_slider_properties.c lv_span_properties.c lv_spinbox_properties.c lv_spinner_properties.c lv_style_properties.c lv_switch_properties.c lv_table_properties.c lv_tabview_properties.c lv_textarea_properties.c
    ../ThirdParty/lvgl/src/widgets/qrcode/: lv_qrcode.c
    ../ThirdParty/lvgl/src/widgets/roller/: lv_roller.c
    ../ThirdParty/lvgl/src/widgets/scale/: lv_scale.c
    ../ThirdParty/lvgl/src/widgets/slider/: lv_slider.c
    ../ThirdParty/lvgl/src/widgets/span/: lv_span.c
    ../ThirdParty/lvgl/src/widgets/spinbox/: lv_spinbox.c
    ../ThirdParty/lvgl/src/widgets/spinner/: lv_spinner.c
    ../ThirdParty/lvgl/src/widgets/switch/: lv_switch.c
    ../ThirdParty/lvgl/src/widgets/table/: lv_table.c
    ../ThirdParty/lvgl/src/widgets/tabview/: lv_tabview.c
    ../ThirdParty/lvgl/src/widgets/textarea/: lv_textarea.c
    ../ThirdParty/lvgl/src/widgets/tileview/: lv_tileview.c
  group FatFs
    ../ThirdParty/fatfs/src/: ff.c diskio.c ffunicode.c
  group APP
    ../APP/: app_cli.c app_ui_files.c app.c
  group USB_MSC
    ../FWLIB/GD32F4xx_usb_library/driver/Source/: drv_usb_core.c drv_usb_dev.c drv_usbd_int.c
    ../FWLIB/GD32F4xx_usb_library/device/core/Source/: usbd_core.c usbd_enum.c usbd_transc.c
    ../FWLIB/GD32F4xx_usb_library/device/class/msc/Source/: usbd_msc_bbb.c usbd_msc_core.c usbd_msc_scsi.c
  group CMSIS
    ../CMSIS/: core_cm4.h gd32f4xx_libopt.h
    ../CMSIS/GD/GD32F4xx/Include/: gd32f4xx.h system_gd32f4xx.h
    ../CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
  group FWLIB
    ../FWLIB/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
